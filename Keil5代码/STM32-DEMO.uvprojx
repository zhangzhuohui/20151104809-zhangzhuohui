# Keil uVision project STM32-DEMO.uvprojx, settings and files
target USART1-DEMO (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-DEMO +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CMSIS;..\FWlib\inc;..\USER;..\SYSTEM\sys;..\FWlib\src;..\HARDWARE\usart2;..\SYSTEM\delay;..\HARDWARE\LED;..\HARDWARE\usart3;..\HARDWARE\MFRC522;..\HARDWARE\SPI;..\HARDWARE\WT588D;..\HARDWARE\stmflash;..\HARDWARE\ADC;..\HARDWARE\TIMER;..\HARDWARE\oled;..\HARDWARE\DHT11;..\HARDWARE\ESP8266;..\HARDWARE\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c usart1.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_tim.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group HARDWARE
    ../HARDWARE/usart2/: usart2.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/usart3/: usart3.c
    ../HARDWARE/MFRC522/: rc522.c rc522_add.c
    ../HARDWARE/WT588D/: WT588D.c
    ../HARDWARE/stmflash/: stmflash.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/oled/: codetab.h
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/ESP8266/: bsp_esp8266.c
    ../HARDWARE/Common/: Common.c
software components: CMSIS:CORE 4.3.0
